# Keil uVision project kl46pedometer.uvprojx, settings and files
target mkl46 (ARM-ADS)
  device: MKL36Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: kl46pedometer +hex
  c flags: Optim=1
  c define: MKL46Z4 CMSIS
  c misc: --c99
  c include: ..\drivers\inc;..\startup\CoreSupport;..\startup\DeviceSupport;..\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group startup
    ../startup/DeviceSupport/: startup_MKL46Z4.s system_MKL46Z4.c
  group user
    ../src/: main.c
  group drivers
    ../drivers/src/: button.c common.c data_storage.c dht11.c flash.c gpio.c i2c0.c isr.c lptmr.c mma8652fc.c slcd.c smc.c step.c systick.c timer.c uart.c
